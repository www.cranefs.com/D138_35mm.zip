# Autodesk Inventor part: 145840-35mm
## iProperties
Created: 2011-08
Part Number: 145840-35mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
